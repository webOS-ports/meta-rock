SRC_URI = "${OPENWEBOS_GIT_REPO}/${PN};branch=master;protocol=git"
