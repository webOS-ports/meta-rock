PREMIRRORS_append () {
cvs://.*/.* http://static.silentbluesystems.com/source/
svn://.*/.* http://static.silentbluesystems.com/source/
git://.*/.* http://static.silentbluesystems.com/source/
hg://.*/.*  http://static.silentbluesystems.com/source/
bzr://.*/.* http://static.silentbluesystems.com/source/
ftp://.*/.*     http://static.silentbluesystems.com/source/
https?$://.*/.* http://static.silentbluesystems.com/source/
}