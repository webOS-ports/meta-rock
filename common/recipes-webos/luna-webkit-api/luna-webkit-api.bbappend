PR_append = "+wop-rock+gitr${SRCPV}"
SRC_URI = "git://github.com/halfhalo/${PN};branch=halfhalo/master;protocol=git"
SRCREV="${AUTOREV}"