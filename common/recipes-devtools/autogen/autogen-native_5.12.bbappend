PREFERRED_VERSION_guile-native ?= "2.0.6"