PRINC := "${@int(PRINC) + 6}"
SRC_URI_slate = "${OPENWEBOS_GIT_REPO}/${PN};branch=master;protocol=git"
SRCREV_slate = "ef03c96d0d38d159a4299ed710cfffb9c8020ba4"
