require mesa-common.inc
require mesa-8.0.5.inc
require mesa-dri.inc
PR = "${INC_PR}.0"
