DEPENDS = "util-macros"
PRINC := "${@int(PRINC) + 1}"
