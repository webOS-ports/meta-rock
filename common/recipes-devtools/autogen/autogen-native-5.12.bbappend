PREFERRED_VERSION_guile-native ?= "2%"