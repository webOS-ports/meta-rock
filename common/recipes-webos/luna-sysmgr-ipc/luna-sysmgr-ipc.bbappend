PR_append_x86 = "+rock+gitr${SRCPV}"
SRCREV_x86 ="${AUTOREV}"