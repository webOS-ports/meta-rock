PR_append_slate = "+wop-rock+gitr${SRCPV}"
SRC_URI_slate = "git://github.com/halfhalo/${PN};branch=master;protocol=git"
SRCREV_slate ="${AUTOREV}"